<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>icecast</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>streamsink_streamsink</key>
<param><key>id</key><value>streamsink</value></param>
<param><key>address</key><value>127.0.0.1</value></param>
<param><key>bitrate</key><value>128</value></param>
<param><key>icecast_mountpoint</key><value>/stream</value></param>
<param><key>icecast_user</key><value>source</value></param>
<param><key>password</key><value>your_password</value></param>
<param><key>port</key><value>8000</value></param>
<param><key>stream_pub</key><value>False</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>type</key><value>icecast</value></param>
<param><key>stream_description</key><value>Your description</value></param>
<param><key>stream_genre</key><value>Your genre</value></param>
<param><key>stream_name</key><value>Your stream name</value></param>
<param><key>stream_url</key><value>www.example.org</value></param>
</block>
<connection><source_block_id>audio_source</source_block_id><sink_block_id>streamsink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
